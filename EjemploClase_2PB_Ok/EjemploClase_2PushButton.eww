<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\EjemploClase_2PB_Ok.ewp</path>
    </project>
    <batchBuild />
</workspace>
