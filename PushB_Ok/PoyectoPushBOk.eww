<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PushButton1Ok.ewp</path>
    </project>
    <batchBuild />
</workspace>
